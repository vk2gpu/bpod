#pragma once

#include <Adafruit_GFX.h>

class BpodScrollFill
{
    public:
        const static int16_t width = 8;
        static void draw(int16_t x, int16_t y, int16_t h, Adafruit_GFX &gfx) {
            size_t offset = y * width * sizeof(uint16_t);
            for ( int16_t dy = 0; dy < h; dy++) {
                for ( int16_t dx = 0; dx < width; dx++) {
                    if ( offset >= 96) offset = 0;
                    gfx.drawPixel(x + dx, y + dy, pixel(offset));
                    offset += sizeof(uint16_t);
                }
            }
        };
        inline static uint16_t pixel(size_t offset) {
            const static char data[96] = {
                0x37, 0x3c, 0xdb, 0x9d, 0xf9, 0x64, 0x58, 0x2c, 0x58, 0x2c, 0xb9, 0x44, 0x1a, 0x55, 0x7b, 0x6d,
                0x37, 0x3c, 0xdb, 0x9d, 0xf9, 0x64, 0x58, 0x2c, 0x58, 0x2c, 0xb9, 0x44, 0x1a, 0x5d, 0x7b, 0x6d,
                0x58, 0x3c, 0xfb, 0xa5, 0x1a, 0x6d, 0x99, 0x3c, 0x99, 0x3c, 0xfa, 0x54, 0x5b, 0x65, 0xbb, 0x75,
                0x98, 0x4c, 0x1c, 0xa6, 0x5a, 0x75, 0xba, 0x44, 0xba, 0x44, 0x3a, 0x55, 0x9b, 0x6d, 0xfc, 0x7d,
                0x98, 0x4c, 0xfc, 0xa5, 0x3a, 0x75, 0xb9, 0x44, 0xb9, 0x44, 0x1a, 0x55, 0x9c, 0x65, 0xfc, 0x7d,
                0x58, 0x3c, 0xfc, 0x9d, 0x1a, 0x6d, 0x79, 0x34, 0x79, 0x34, 0xda, 0x4c, 0x5b, 0x65, 0xbb, 0x75
            };
            return *reinterpret_cast<const uint16_t*>(&data[offset]);
        };

};
